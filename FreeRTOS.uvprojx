# Keil uVision project FreeRTOS.uvprojx, settings and files
target Freertos (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,STM32F4XX,KEIL_IDE,TM_DISCO_STM32F429_DISCOVERY,HSE_VALUE=8000000,PLL_M=8,PLL_N=336,PLL_P=2,PLL_Q=7,USE_USB_OTG_HS
  c include: .\00-STM32F429_LIBRARIES;.\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;.\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;.\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\inc;.\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;.\FreeRTOS\Source\include;.\TM;.\User;.\User\nFR24L01;.\User\MPL115A1;.\User\fatfs;.\User\fatfs\option;.\User\fatfs\drivers;.\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\FreeRTOS\Source\CMSIS_RTOS
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group StartUp
    ./00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group STD_Periph_Drivers
    ./00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_fmc.c stm32f4xx_ltdc.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_tim.c
  group TM
    ./TM/: tm_stm32f4_fonts.c tm_stm32f4_i2c.c tm_stm32f4_l3gd20.c tm_stm32f4_sdram.c tm_stm32f4_spi.c tm_stm32f4_stmpe811.c tm_stm32f4_usart.c tm_stm32f4_ili9341_ltdc.c tm_stm32f4_adc.c tm_stm32f4_bmp180.c tm_stm32f4_gpio.c tm_stm32f4_watchdog.c
    ./00-STM32F429_LIBRARIES/: tm_stm32f4_delay.c tm_stm32f4_disco.c tm_stm32f4_exti.c tm_stm32f4_rtc.c
  group User
    ./User/: freertos.c main.c stm32f4xx_it.c system_stm32f4xx.c sensors.c Book.c
    ./User/nFR24L01/: tm_stm32f4_nrf24l01.c
  group Freertos
    ./FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/Source/portable/MemMang/: heap_4.c
  group FATFS
    ./User/fatfs/: diskio.c ff.c
    ./User/fatfs/drivers/: fatfs_sd.c
    ./User/fatfs/option/: syscall.c unicode.c
